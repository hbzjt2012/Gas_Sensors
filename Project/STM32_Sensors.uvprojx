# Keil uVision project STM32_Sensors.uvprojx, settings and files
target STM32_Sensors (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32_Sensors
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F091
  c include: ..\Source\Application\main;..\Source\STM32_FWLib\FWLib\inc;..\Source\STM32_FWLib\CMSIS;..\Source\Drivers\usart2;..\Source\Drivers\sht30;..\Source\Drivers\w25q64;..\Source\Drivers\led;..\Source\Drivers\delay;..\Source\Drivers\usart1_PM25;..\Source\Drivers\usart3_CO;..\Source\Drivers\usart4_CO2_T6703
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Drivers
    ../Source/Drivers/usart1_PM25/: usart1_PM25.c
    ../Source/Drivers/usart2/: usart2.c
    ../Source/Drivers/usart3_CO/: usart3_CO.c
    ../Source/Drivers/usart4_CO2_T6703/: usart4_CO2_T6703.c
    ../Source/Drivers/sht30/: sht30.c
    ../Source/Drivers/w25q64/: w25q64.c
    ../Source/Drivers/led/: led.c
    ../Source/Drivers/delay/: delay.c
  group Startup
    ../Source/STM32_FWLib/CMSIS/startup/: startup_stm32f091.s
  group Application
    ../Source/Application/main/: main.c stm32f0xx_it.c
  group FWLib
    ../Source/STM32_FWLib/CMSIS/: system_stm32f0xx.c
    ../Source/STM32_FWLib/FWLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
